# Keil uVision project Gamebox.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Gamebox +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: Delay.c Display_Drives.c GUI.c Main.c RAC.c Shot.c snake.c Sound_Drives.c Tetris.c Sound_date.c
